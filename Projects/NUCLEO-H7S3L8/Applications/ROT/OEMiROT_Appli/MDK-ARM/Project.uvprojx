# Keil uVision project Project.uvprojx, settings and files
target STM32H7S78-DK_OEMiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.1.0
  cpu: CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7S78-DK_OEMiROT_Appli
  AfterMake: fromelf "#L" --bincombined --output="$L\..\..\..\Binary\rot_app.bin"
  AfterMake: postbuild.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\STM32H7S78-DK;..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  scatter file: .\stm32h7rsxx_RAMxspi2_ROMxspi1.sct
  link misc: --diag_suppress=L6312,L6314,L6329W
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32h7s7xx.s
  group Application/User
    ../Src/: com.c main.c stm32h7rsxx_it.c
software components: CMSIS:CORE 5.6.0
