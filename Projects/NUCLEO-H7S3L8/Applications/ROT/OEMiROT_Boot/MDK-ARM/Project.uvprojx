# Keil uVision project Project.uvprojx, settings and files
target Nucleo-H7S3L8_OEMiROT_Boot (6210000::V6.21::ARMCLANG)
  device: STM32H7S3L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Nucleo-H7S3L8_OEMiROT_Boot
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv7-m -E -P -xc -DSTM32H7S3xx -DBL2 -I..\..\Linker -I..\Inc -I..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc -I..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include -I..\..\..\..\..\..\Drivers\CMSIS\Core\Include ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  AfterMake: fromelf "#L" --bin --output="$L\..\..\..\Binary\OEMiROT_Boot.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S3xx,NDEBUG,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<config-boot.h>,MCUBOOT_DOUBLE_SIGN_VERIF,FLOW_CONTROL,BL2,DEFAULT_UART_BAUDRATE=115200,OEMIROT_DEV_MODE,BOOT_MAX_ALIGN=16,BL2_USE_SFDP_EXT_FLASH_INFO
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS/Device\ST\STM32H7RSxx\Include;..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include;..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls;..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\hal\Inc;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\mbedtls-asn1\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver;..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager;..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\nor_sfdp;..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\psram;..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\sal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7rsxx_bl2.sct
  link misc: --predefine=-I../Inc/


--predefine=-DBL2
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_rng_ex.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_hash.c stm32h7rsxx_hal_pka.c stm32h7rsxx_hal_mce.c stm32h7rsxx_hal_ramecc.c stm32h7rsxx_hal_xspi.c
  group Application/User
    ../Src/: low_level_flash.c low_level_com.c low_level_rng.c tick.c boot_hal.c low_level_device.c stm32h7rsxx_hal_msp.c keys_map.c low_level_ext_ram.c low_level_ramecc.c low_level_security.c bl2_nv_services.c low_level_obkeys.c low_level_obkeys_device.c low_level_mce.c low_level_extmem_device.c low_level_ext_flash.c startup_stm32h7rsxx.c
  group Middlewares/mbed-crypto/LIBRARY
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c bignum.c cipher.c constant_time.c ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c rsa.c rsa_internal.c sha256.c asn1write.c cipher_wrap.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
  group Middlewares/STM32_ExtMem
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem/PSRAM
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem/SAL
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem/NOR_SFDP
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
software components: CMSIS:CORE 5.6.0
